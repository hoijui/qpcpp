# IAR project game.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S811 Luminary LM3S811
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_LM3S811; STACK_SIZE=600
  ICCARM.CCDiagSuppress: Pa050,Pe368
  ICCARM.CCIncludePath2: .; $_QPCPP_$\include; $_QPCPP_$\ports\arm-cortex\qk\iar; cmsis
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: game.bin
  ILINK.IlinkOutputFile: game.out
  ILINK.IlinkIcfFile: lm3s811.icf
  ILINK.IlinkAdditionalLibs: $_QPCPP_$\ports\arm-cortex\vanilla\iar\dbg\libqep_cortex-m3.a; $_QPCPP_$\ports\arm-cortex\vanilla\iar\dbg\libqf_cortex-m3.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; PART_LM3S811; NDEBUG; STACK_SIZE=600
  ILINK.IlinkAdditionalLibs: $_QPCPP_$\ports\arm-cortex\vanilla\iar\rel\libqep_cortex-m3.a; $_QPCPP_$\ports\arm-cortex\vanilla\iar\rel\libqf_cortex-m3.a
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; PART_LM3S811; Q_SPY; STACK_SIZE=600
  ILINK.IlinkAdditionalLibs: $_QPCPP_$\ports\arm-cortex\vanilla\iar\spy\libqep_cortex-m3.a; $_QPCPP_$\ports\arm-cortex\vanilla\iar\spy\libqf_cortex-m3.a; $_QPCPP_$\ports\arm-cortex\vanilla\iar\spy\libqs_cortex-m3.a
  group CMSIS
    cmsis/: core_cm3.c core_cm3.h lm3s_cmsis.h startup_ewarm.c system_lm3s.c system_lm3s.h
  group Source
    ./: bsp.cpp bsp.h display96x16x1.c display96x16x1.h game.h lm3s_config.h main.cpp mine1.cpp mine2.cpp missile.cpp ship.cpp tunnel.cpp
